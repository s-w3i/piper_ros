Commit message: 🐞 fix(piper_x_v3_urdf): joint6的Z轴旋转方向定义反了

File: src/piper_x_description_v3/urdf/piper_x_description_v3.urdf (robot description, URDF)
Before this commit: robot piper_x_description_v3, 9 links, 8 joints
Joints:
- joint joint6: axis 0 0 -1 -> 0 0 1
